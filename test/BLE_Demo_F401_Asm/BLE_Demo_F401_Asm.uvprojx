# Keil uVision project BLE_Demo_F401_Asm.uvprojx, settings and files
target BLE_Demo_F401_Asm (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F401RE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BLE_Demo_F401_Asm +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Startup
    ./: startup_stm32f401xe.s
  group Application Assembly
    ./: main.s
